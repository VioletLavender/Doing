# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Source\BSP\inc;.\Source\Device\CMSIS\Inc;.\Source\Device\STM32F4xx\include\Inc;.\Source\Device\STM32F4xx\startup\Inc;.\Source\Device\STM32F4xx\STM32F4xx_Std_Driver\inc;.\Source\SYS\inc;.\Source\Utility\FatFs_R0.14\source;.\Source\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./Source/Device/STM32F4xx/startup/: system_stm32f4xx.c startup_stm32f40_41xxx.s
    ./Source/Device/STM32F4xx/include/: stm32f4xx_it.c
  group APP
    ./Source/APP/src/: main.c
  group BSP
    ./Source/BSP/src/: sdcard.c spi.c test.c
  group SYS
    ./Source/SYS/src/: delay.c sys.c usart.c
  group STM32F4xx_Std_Driver
    ./Source/Device/STM32F4xx/STM32F4xx_Std_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Fatfs
    ./Source/Utility/FatFs_R0.14/source/: diskio.c ff.c ffsystem.c ffunicode.c
